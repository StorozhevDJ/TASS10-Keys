<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\tokoproimnik_tass10_v2.0.ewp</path>
  </project>
  <batchBuild/>
</workspace>


