# IAR project tokoproimnik_tass10_v2.0.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407VE ST STM32F407VE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER
  ICCARM.PreInclude: stm32f4xx.h
  ICCARM.CCIncludePath2: Config\; Libraries\CMSIS\Include\; Libraries\CMSIS\Device\ST\STM32F4xx\Include\; Libraries\STM32F4xx_StdPeriph_Driver\inc\; Libraries\; Libraries\FreeRTOS\include\; Libraries\FreeRTOS\portable\IAR\ARM_CM4F\; Source\
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 1
  OBJCOPY.OOCOutputFile: 5.srec
  ILINK.IlinkOutputFile: cpp.out
  ILINK.IlinkIcfFile: stm32f407xE.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ./: main.cpp main.hpp
    Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/iar/: startup_stm32f40xx.s
    Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group Config
    Config/: FreeRTOSConfig.h stm32f4xx.h stm32f4xx_conf.h stm32f4xx_it.c stm32f4xx_it.h
  group Lib/AD779x
    Libraries/AD779x/: drv_ad7794_98_99.c drv_ad7794_98_99.h
  group Lib/Filter
    Libraries/Filter/: Filter.c Filter.h
  group Lib/FreeRtos
    Libraries/FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group Lib/FreeRtos/inc
    Libraries/FreeRTOS/include/: croutine.h event_groups.h FreeRTOS.h list.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h StackMacros.h task.h timers.h
  group Lib/FreeRtos/Port
    Libraries/FreeRTOS/portable/IAR/ARM_CM4F/: port.c portasm.s portmacro.h
  group Lib/FreeRtos/Port/MemMang
    Libraries/FreeRTOS/portable/MemMang/: heap_1.c heap_2.c heap_3.c heap_4.c
  group Lib/STM32F4xx_StdPeriph_Driver/inc
    Libraries/STM32F4xx_StdPeriph_Driver/inc/: misc.h stm32f4xx_adc.h stm32f4xx_can.h stm32f4xx_crc.h stm32f4xx_cryp.h stm32f4xx_dac.h stm32f4xx_dbgmcu.h stm32f4xx_dcmi.h stm32f4xx_dma.h stm32f4xx_dma2d.h stm32f4xx_exti.h stm32f4xx_flash.h stm32f4xx_fmc.h stm32f4xx_fsmc.h stm32f4xx_gpio.h stm32f4xx_hash.h stm32f4xx_i2c.h stm32f4xx_iwdg.h stm32f4xx_ltdc.h stm32f4xx_pwr.h stm32f4xx_rcc.h stm32f4xx_rng.h stm32f4xx_rtc.h stm32f4xx_sai.h stm32f4xx_sdio.h stm32f4xx_spi.h stm32f4xx_syscfg.h stm32f4xx_tim.h stm32f4xx_usart.h stm32f4xx_wwdg.h
  group Lib/STM32F4xx_StdPeriph_Driver/src
    Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_fmc.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group Lib/ZigBee
    Libraries/ZigBee/: ZigBee_API.cpp ZigBee_API.hpp ZigBee_API_Driver.cpp ZigBee_API_Driver.hpp
  group Source
    Source/: Communication.cpp Communication.hpp InOut.cpp InOut.hpp Measure.cpp Measure.hpp Power.cpp Power.hpp PWM.cpp PWM.hpp Sensors.cpp Sensors.hpp Work.cpp Work.hpp
